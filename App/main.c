/*>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>
* 文件名  ： main
* 作者    ： HuangShuyi
* 版本    ： V1.0.0
* 时间    ： 2020/10/14
* 简要    ： 主函数所在文件，程序的入口  
********************************************************************
* 副本
*
*>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>*/
/* 头文件 ----------------------------------------------------------------*/
//#include "main.h"
#include "led.h"
//#include "ioCC2530.h" 
/* 宏定义 ----------------------------------------------------------------*/
//#define LED1 P1_0     // P1_0定义为P1.0
//#define LED2 P1_1     // P1_1定义为P1.1
/* 结构体或枚举 ----------------------------------------------------------*/
/* 内部函数声明 ----------------------------------------------------------*/
void Delay(unsigned int time);


unsigned int tmp = 0;
/* 函数 ------------------------------------------------------------------*/
/*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
* 函数名：Delay
* 参数：unsigned int time
* 返回：void
* 描述：延迟函数
~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/
//1ms精确定时
void Delay(unsigned int time)
{
    unsigned int i = 0;
    unsigned int j;
    for(i = 0; i < time; i++)
    {
        for(j = 0; j < 475; j++)
        {  
            asm("NOP");   
            asm("NOP");
            asm("NOP");
        } 
    }
}
/*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
* 函数名：main
* 参数：void
* 返回：void
* 描述：主函数/入口函数
~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/
void main(void)
{
/*
    P1SEL &= ~(0x03);
    P1DIR |= 0x03 ;   
    while(1)
    {
        LED1 = 1;    
        LED2 = 0;  
        Delay(1000);
        LED1 = 0;    
        LED2 = 1;   
        Delay(1000);
    } */
    LedInit();
    while(1)
    {
        LedOn(LED_D1_E);
        Delay(1000);
        LedOn(LED_D2_E);
        Delay(1000);
        LedOn(LED_D3_E);
        Delay(1000);
        LedInit();
        LedOn(LED_ALL_E);
        Delay(1000);
        LedInit();
    }
}
